# IAR project AD-15_BOOT.ewp, settings and files
configuration bootloader (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac NordicSemi nrf51422_xxac
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_AES=1; DEBUG=0; WTD_EN=1; FLASH_WRP=0; ENABLE_DEBUG_LOG_SUPPORT; BLE_STACK_SUPPORT_REQD; S130; NRF_LOG_USES_UART=1; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\BSP; ..\APP\RFID; ..\APP\bootloader; ..\APP\inc; ..\APP\tiny-AES128; ..\BSP\config; ..\SDK\drivers_nrf\hal; ..\SDK\drivers_nrf\uart; ..\SDK\drivers_nrf\gpiote; ..\SDK\drivers_nrf\config; ..\SDK\drivers_nrf\common; ..\SDK\drivers_nrf\timer; ..\SDK\drivers_nrf\ppi; ..\SDK\drivers_nrf\delay; ..\SDK\drivers_nrf\pstorage; ..\SDK\drivers_nrf\wdt; ..\SDK\drivers_nrf\rng; ..\SDK\drivers_nrf\spi_master; ..\SDK\drivers_nrf\twi_master; ..\SDK\libraries\util; ..\SDK\libraries\fifo; ..\SDK\libraries\timer; ..\SDK\libraries\trace; ..\SDK\libraries\button; ..\SDK\libraries\uart; ..\SDK\libraries\pwm; ..\SDK\libraries\ic_info; ..\SDK\BLE\common; ..\SDK\ble\ble_services\ble_nus; ..\SDK\ble\ble_advertising; ..\SDK\device; ..\SDK\toolchain; ..\SDK\softdevice\common\softdevice_handler; ..\SDK\softdevice\s130\headers; ..\SDK\softdevice\s130\headers\nrf51; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AD-15_BOOT.hex
  ILINK.IlinkOutputFile: AutoStand.out
  ILINK.IlinkIcfFile: AD-15_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../APP/tiny-AES128/: aes.c
    ../APP/bootloader/: bootloader.c main_boot.c protocol_boot.c
    ../APP/src/: command.c control.c prjlib.c RTC.c user_ble.c user_uart.c
  group BSP
    ../BSP/: bsp.c
  group Device
    ../SDK/toolchain/iar/: iar_startup_nrf51.s
    ../SDK/toolchain/: system_nrf51.c
  group nRF_BLE
    ../SDK/ble/common/: ble_advdata.c ble_srv_common.c
    ../SDK/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../SDK/drivers_nrf/hal/: nrf_adc.c nrf_nvmc.c
    ../SDK/drivers_nrf/delay/: nrf_delay.c
    ../SDK/drivers_nrf/common/: nrf_drv_common.c
    ../SDK/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../SDK/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../SDK/drivers_nrf/rng/: nrf_drv_rng.c
    ../SDK/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../SDK/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../SDK/drivers_nrf/uart/: nrf_drv_uart.c
    ../SDK/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../SDK/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_Libraries
    ../SDK/libraries/button/: app_button.c
    ../SDK/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ../SDK/libraries/fifo/: app_fifo.c
    ../SDK/libraries/timer/: app_timer.c
    ../SDK/libraries/trace/: app_trace.c
    ../SDK/libraries/uart/: app_uart_fifo.c retarget.c
    ../SDK/libraries/ic_info/: nrf_ic_info.c
  group nRF_SoftDevice
    ../SDK/softdevice/common/softdevice_handler/: softdevice_handler.c
