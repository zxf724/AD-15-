<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AD-15.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\AD-15_BOOT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


