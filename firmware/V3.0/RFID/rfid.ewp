# IAR project rfid.ewp, settings and files
configuration rfid (STM8)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0
  ICCSTM8.CCIncludePath2: App; Bsp; STM8S_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 刷卡机_V1.0.0.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    App/: app.c main.c MFRC522_API.c prjlib.c stm8s_it.c
  group Bsp
    Bsp/: bsp.c MFRC522_Dev.c MFRC522_SPI.c timer.c uart.c
  group Doc
    Doc/: ReadMe.txt
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
